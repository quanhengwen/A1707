# Keil uVision project project.uvprojx, settings and files
target A1707_APP (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: STM32F103RE STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.2.0
  cpu: IRAM(0x20000000,0x10000) IROM(0x08000000,0x80000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: rtthread-stm32 +hex
  c flags: Optim=1 OneElfS=1 uC99=1 uGnu=1 v6Lang=1 v6LangP=1
  c define: USE_STDPERIPH_DRIVER,STM32F10X_HD,MPL_LOG_NDEBUG=1,EMPL,MPU9250,EMPL_TARGET_STM32F4
  c include: .;.\app;..\stm32f103;..\..\components\drivers\include;..\..\components\finsh;..\..\include;..\..\libcpu\arm\common;..\..\libcpu\arm\cortex-m3;..\..\Libraries\CMSIS\CM3\DeviceSupport\ST\STM32F10x;..\..\Libraries\STM32F10x_StdPeriph_Driver\inc;..\..\drivers;..\..\Libraries\CMSIS\CM3\CoreSupport;..\..\common_lib;.\startup;.\app;..\..\general_app;.\DMP\driver\include;.\DMP\mpl;.\DMP\mllite;.\DMP\eMPL-hal;.\DMP\driver\stm32L;.\DMP\driver\eMPL
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x10000
  link misc: --keep __fsym_*
  group app
    ./app/: app_board.c application.c param.c stm32f10x_it.c canbus_middle.c drv_max9611.c app_current_detect.c drv_stepper_motor.c drv_mpu9250.c imu.c report.c drv_timer.c stepper_ctrl.c hall_detect.c
  group Drivers
    ../../drivers/: startup.c cpuusage.c drv_board.c serial.c usart.c swo.c iap_if.c flash_if.c drv_18b20.c drv_adc.c drv_breathe_led.c drv_com_uart.c drv_input.c drv_InRTC.c drv_MixRTC.c drv_simu_i2c.c drv_switch.c drv_watchdog.c drv_can.c
  group STM32_StdPeriph
    ../../Libraries/CMSIS/CM3/DeviceSupport/ST/STM32F10x/startup/arm/: startup_stm32f10x_hd.s
    ../../Libraries/CMSIS/CM3/DeviceSupport/ST/STM32F10x/: system_stm32f10x.c
    ../../Libraries/STM32F10x_StdPeriph_Driver/src/: misc.c stm32f10x_adc.c stm32f10x_bkp.c stm32f10x_can.c stm32f10x_cec.c stm32f10x_crc.c stm32f10x_dac.c stm32f10x_dbgmcu.c stm32f10x_dma.c stm32f10x_exti.c stm32f10x_flash.c stm32f10x_fsmc.c stm32f10x_gpio.c stm32f10x_i2c.c stm32f10x_iwdg.c stm32f10x_pwr.c stm32f10x_rcc.c stm32f10x_rtc.c stm32f10x_sdio.c stm32f10x_spi.c stm32f10x_tim.c stm32f10x_usart.c stm32f10x_wwdg.c
  group Kernel
    ../../src/: clock.c device.c idle.c ipc.c irq.c kservice.c mem.c mempool.c object.c scheduler.c thread.c timer.c memheap.c
  group CORTEX-M3
    ../../libcpu/arm/cortex-m3/: cpuport.c context_rvds.S
  group finsh
    ../../components/finsh/: cmd.c finsh_compiler.c finsh_error.c finsh_heap.c finsh_init.c finsh_node.c finsh_ops.c finsh_parser.c finsh_token.c finsh_var.c finsh_vm.c shell.c symbol.c
  group Src
    ../../components/drivers/src/: completion.c dataqueue.c pipe.c portal.c ringbuffer.c workqueue.c
  group common_lib
    ../../common_lib/: usdl_bit.c usdl_buf.c usdl_calc.c usdl_conversion.c usdl_data.c usdl_io.c usdl_list.c usdl_mem.c usdl_string.c usdl_time.c usdl_tools.c
  group general_app
    ../../general_app/: protocol_anylise_frame.c uart_ota_protocol.c can_ota_protocol.c can_search_protocol.c can_heartbeat_protocol.c can_debug_protocol.c manage_id.c
  group DMP
    ./DMP/driver/eMPL/: inv_mpu.c inv_mpu_dmp_motion_driver.c
    ./DMP/driver/stm32L/: log_stm32.c
    ./DMP/eMPL-hal/: eMPL_outputs.c
    ./DMP/mllite/: data_builder.c hal_outputs.c message_layer.c ml_math_func.c mlmath.c mpl.c results_holder.c start_manager.c storage_manager.c
    ./DMP/mpl/: libmpllib.lib
target A1707_IAP (5060422::V5.06 update 4 (build 422)::ARMCC)
  device: STM32F103VE STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.2.0
  cpu: as above
  output: rtthread-stm32 +hex
  AfterMake: fromelf --bin !L --output A1707_VARI3101.bin
  c flags: Optim=1 OneElfS=1 v6Lang=1 v6LangP=1
  c define: USE_STDPERIPH_DRIVER,STM32F10X_HD,USE_IAP
  c include: .;.\app;..\stm32f103;..\..\components\drivers\include;..\..\components\finsh;..\..\include;..\..\libcpu\arm\common;..\..\libcpu\arm\cortex-m3;..\..\Libraries\CMSIS\CM3\DeviceSupport\ST\STM32F10x;..\..\Libraries\STM32F10x_StdPeriph_Driver\inc;..\..\drivers;..\..\Libraries\CMSIS\CM3\CoreSupport;..\..\common_lib;.\startup;.\app;..\..\general_app
  library: MicroLIB
  memory RVCT4: ROM 0x800a000 size 0x100000
  memory RVCT9: RAM 0x20000000 size 0x18000
  link misc: --keep __fsym_*
